# Keil uVision project RS485.uvprojx, settings and files
target RS485 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RS485 +hex
  c flags: Optim=1
  c define: VECT_TAB_FLASH
  c include: .\FWLib;.\Soure
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Soure
    ./Soure/: main.c stm32f10x_it.c Led.c CBase.c UART.c
  group FWLib
    ./FWLib/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group RVMDK
    ./RVMDK/: cortexm3_macro.s stm32f10x_vector.s
